# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS53 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(12000000) MODA2
  output: Project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Project/: Project.c
